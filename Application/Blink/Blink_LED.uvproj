# Keil uVision project Blink_LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Blink_LED
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
  group Application
    ../: App.c App.h
  group MCAL
    ../../MCAL/DIO/: Dio.c Dio.h
    ../../MCAL/GPIO/: GPIO.c GPIO.h
    ../../MCAL/TYPES/: types.h
    ../../MCAL/GPTM/: GPTM.c GPTM.h
    ../../MCAL/INT_CTRL/: INTCtrl.c INTCtrl.h
    ../../MCAL/MCU/: MCU.c MCU.h
